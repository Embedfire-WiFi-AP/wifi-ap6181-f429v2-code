# Keil uVision project BH-F429.uvprojx, settings and files
target AP6181 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YH-F429
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,DEBUG ,USE_RTOS=1,WICED_DISABLE_BOOTLOADER, OV5640
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\ver9.0.0\Source\include;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\ver9.0.0\Source;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\ver9.0.0\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\WiFi_SDk\WICED\network\LwIP\ver2.0.3\port;..\..\..\WiFi_SDk\WICED\network\LwIP\ver2.0.3\src;..\..\..\WiFi_SDk\WICED\network\LwIP\ver2.0.3\src\include;..\..\lwip\contrib\apps;..\..\..\WiFi_SDk\include;..\..\..\WiFi_SDk\libraries\utilities\linked_list;..\..\..\WiFi_SDk\libraries\utilities\TLV;..\..\..\WiFi_SDk\resources\firmware\43362;..\..\..\WiFi_SDk\WICED\internal\unit;..\..\..\WiFi_SDk\WICED\internal;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD\FreeRTOS;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD\FreeRTOS\arch;..\..\..\WiFi_SDk\WICED\platform\MCU\STM32F4xx;..\..\..\WiFi_SDk\WICED\platform\include;..\..\..\WiFi_SDk\WICED\platform\MCU\STM32F4xx;..\..\..\WiFi_SDk\WICED\platform\MCU\STM32F4xx\peripherals;..\..\..\WiFi_SDk\WICED\platform\MCU\STM32F4xx\WWD;..\..\..\WiFi_SDk\WICED\WWD\include;..\..\..\WiFi_SDk\WICED\WWD\include\network;..\..\..\WiFi_SDk\WICED\WWD\include\platform;..\..\..\WiFi_SDk\WICED\WWD\include\RTOS;..\..\..\WiFi_SDk\WICED\WWD;..\..\..\WiFi_SDk\WICED\WWD\internal\bus_protocols;..\..\..\WiFi_SDk\WICED\WWD\internal\bus_protocols\SDIO;..\..\..\WiFi_SDk\WICED\WWD\internal\chips\43362;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\WWD;..\..\..\WiFi_SDk\WICED\WWD\internal;..\..\..\WiFi_SDk\WICED\platform\GCC;..\..\..\WiFi_SDk\WICED\security\BESL\crypto_internal;..\..\..\WiFi_SDk\WICED\security\BESL\mbedtls_open\include;..\..\..\WiFi_SDk\WICED\security\BESL\include;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\WICED;..\..\..\WiFi_SDk\WICED\platform\MCU;..\..\..\WiFi_SDk\libraries\utilities\ring_buffer;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\WWD\ARM_CM4F;..\..\..\WiFi_SDK\libraries\inputs\gpio_button;..\..\..\WiFi_SDk\WICED\network\LwIP\WICED;..\..\..\WiFi_SDk\WICED\security\BESL\host\WICED;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD\FreeRTOS\arch;..\..\..\WiFi_SDk\WICED\security\PostgreSQL\include;..\..\..\WiFi_SDK\WICED\RTOS\FreeRTOS\WWD\ARM_CM7;..\..\User\cm_backtrace\fault_handler\keil;..\..\User\cm_backtrace;..\..\..\WiFi_SDK\WICED\platform\MCU\STM32F4xx;..\..\User\ov5640;..\..\User\SDRAM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\User\fire_demo.sct
  group DOC
    ../../: 必读说明.txt
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h wifi_base_config.c appliance.c tcpecho.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../../WiFi_SDK/WICED/network/LwIP/WWD/FreeRTOS/: lwipopts.h
    ../../User/SDRAM/: bsp_sdram.c
    ../../User/delay/: core_delay.c
  group Camera
    ../../User/: camera_data_queue.c tcp_server.c
    ../../User/ov5640/: ov5460_SCCB.c ov5640_AF.c ov5640_Init.c bsp_ov5640.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_dma.c misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_qspi.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group FreeRTOS-Source-include
    ../../../WiFi_SDK/WICED/RTOS/FreeRTOS/ver9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS-Source
    ../../../WiFi_SDK/WICED/RTOS/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS-Source-portable
    ../../../WiFi_SDK/WICED/RTOS/FreeRTOS/ver9.0.0/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../WiFi_SDK/WICED/RTOS/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_4.c
  group lwip-port
    ../../../WiFi_SDK/WICED/network/LwIP/WWD/FreeRTOS/: sys_arch.c
  group lwip-src-api
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-ipv4
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-ipv6
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-priv
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
  group WiFi
    ../../../WiFi_SDK/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../../../WiFi_SDK/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c
    ../../../WiFi_SDK/WICED/WWD/internal/chips/43362/: wwd_ap.c wwd_chip_specific_functions.c
    ../../../WiFi_SDK/WICED/WWD/internal/: wwd_ap_common.c wwd_debug.c wwd_eapol.c wwd_internal.c wwd_logging.c wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_thread.c wwd_thread_internal.c wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_sleep.c
    ../../../WiFi_SDK/WICED/RTOS/FreeRTOS/WWD/: wwd_rtos.c
    ../../../WiFi_SDK/WICED/platform/MCU/: platform_resource.c wwd_resources.c wwd_platform_separate_mcu.c
    ../../../WiFi_SDK/WICED/platform/ARM_CM4/: host_cm4.c
    ../../../WiFi_SDK/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_network.c
    ../../../WiFi_SDK/libraries/utilities/TLV/: tlv.c
    ../../../WiFi_SDK/libraries/utilities/ring_buffer/: ring_buffer.c
    ../../../WiFi_SDK/WICED/internal/: wiced_lib.c wiced_crypto.c
    ../../../WiFi_SDK/WICED/platform/MCU/STM32F4xx/WWD/: wwd_platform.c
    ../../User/: 43362A2_bin.c
  group WiFi-sdio
    ../../../WiFi_SDK/WICED/platform/MCU/STM32F4xx/WWD/: wwd_SDIO.c platform.c
    ../../../WiFi_SDK/WICED/platform/MCU/STM32F4xx/peripherals/: platform_gpio.c platform_mcu_powersave.c platform_adc.c platform_audio_timer.c platform_ext_memory.c platform_gspi_master.c platform_i2c.c platform_pwm.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
    ../../../WiFi_SDK/WICED/platform/MCU/: platform_stdio.c
    ../../../WiFi_SDK/WICED/platform/MCU/STM32F4xx/: platform_init.c platform_config.h
    ../../../WiFi_SDK/WICED/RTOS/FreeRTOS/WWD/ARM_CM7/: low_level_init.c
  group Cmbacktrace
    ../../User/cm_backtrace/: cm_backtrace.c
    ../../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
